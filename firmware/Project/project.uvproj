# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\BSP;..\MCU;..\FATFS
  group APP
    ../APP/: main.c app.c
  group BSP
    ../BSP/: led.c tick.c buzzer.c uart.c adc.c i2c.c spi.c oled.c font.c bsp_key.c bsp_rtc.c bsp_gps.c bsp_bat.c bsp_sens.c bsp_ui.c bsp_pms.c bsp_wind.c bsp_noise.c bsp_modbus.c
  group FatFs
    ../FATFS/: ff.c diskio.c
    ../BSP/: bsp_log.c
